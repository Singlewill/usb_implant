# Keil uVision project usb_implant2.0.uvprojx, settings and files
target MAIN (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_implant2.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: ..\Library\STM32_USB_Device_Library\Class\msc\inc;..\Library\STM32_USB_Device_Library\Core\inc;..\Library\STM32_USB_OTG_Driver\inc;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Library\STM3240_41_G_EVAL;..\APP\inc;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\FATFS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/src/: app.c stm32fxxx_it.c system_stm32f4xx.c usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c delay.c usart.c led.c keyboard_fun.c
  group CORE
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USB_DEVICE_LIBRARY
    ../Library/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Library/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_LOW_LEVEL_DRIVER
    ../Library/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_EVAL
    ../Library/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_rcc.c
  group FATFS
    ../Library/FATFS/: diskio.c ff.c
    ../Library/FATFS/option/: cc936.c
software components: CMSIS:CORE 5.1.1
